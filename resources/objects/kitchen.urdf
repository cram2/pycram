Commit message: [tests] Added tests and fixed broken notebook

File: resources/objects/kitchen.urdf (robot description, URDF)
Before this commit: robot iai_oven_area, 84 links, 83 joints
Links:
- link kitchen_island_surface: geometry collision box size=0.8 2.45 0.04
