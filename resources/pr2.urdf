Commit message: added file for node to request kdl

File: resources/pr2.urdf (robot description, URDF)
Before this commit: robot pr2, 88 links, 87 joints
Joints:
- joint torso_lift_joint: type fixed -> prismatic
